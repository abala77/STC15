# Keil uVision project WatchDog.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: WatchDog +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: .\App;.\User
  group Source Group 1
    ./User/: main.c Public.c SysInit.c IIC.c
    ./App/: IO_Mode.c UART1.c CRC16.c ModbusRTU.c Timer0.c UART2.c WiFi.c Key1.c TM1620.c PWM.c ADC.c EEPROM.c 24C02.c NTC.c Watchdog.c
