# Keil uVision project IO_Control.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IO_Control +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\User
  group Source Group 1
    ./User/: main.c Public.c
    ./App/: IO_Mode.c
